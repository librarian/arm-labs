# IAR project GPIO.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2368 NXP LPC2368
  ICCARM.CCDiagSuppress: Pe111,Pa082
  ICCARM.CCIncludePath2: ..\common\inc\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkIcfFile: icf\LPC2368_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_Debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: MotherBoard.srec
  ILINK.IlinkIcfFile: icf\LPC2368_flash.icf
  group (top)
    ./: cstartup.s ExtInterrupts.c irq.c main.c Timers.c uart.c WH1602D.c
